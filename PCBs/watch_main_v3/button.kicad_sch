File: PCBs/watch_main_v3/button.kicad_sch (KiCad schematic)
At the start: 2 parts, among them SW1501 EVP-AEJB2A

Commit message: PCB V3 progress
Parts:
- renumbered C210 to C1501
