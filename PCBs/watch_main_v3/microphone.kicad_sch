File: PCBs/watch_main_v3/microphone.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: PCB V3 progress
Parts:
- renumbered C1801 to C1201, MIC1801 to MIC1201
